# Keil uVision project ContextSwitch2.uvproj, settings and files
target AwesomeOS SIM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ContextSwitch2
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./src/: startup_LPC17xx.s
  group System Code
    ./src/: system_LPC17xx.c
  group Source Code
    ./src/: HAL.c main_svc.c process.c Retarget.c memory.c message.c uart_irq.c sys_proc.c test_proc.c utilities.c
target AwesomeOS RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: ContextSwitch2
  c flags: Optim=1
  c define: DEBUG_0
  memory RVCT4: ROM 0x10000000 size 0x2000
  memory RVCT9: RAM 0x10002000 size 0x6000
  memory RVCT10: RAM 0x2007c000 size 0x8000
